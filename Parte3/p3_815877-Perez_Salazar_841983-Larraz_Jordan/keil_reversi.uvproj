# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  scatter file: keil_reversi.sct
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c Power_management.c Power_management.h boton_eint0.c boton_eint0.h timer0.c timer0.h
  group Drivers
    ./: temporizador_drv.h temporizador_drv.c
  group HAL
    ./: temporizador_hal.h temporizador_hal.c gpio_hal.h int_externas_hal.h int_externas_hal.c Watchdog.h Watchdog.c
  group AUX
    ./: io_reserva.h eventos.h fifo.h fifo.c planificador.h planificador.c botones.h botones.c
  group hello_world
    ./: hello_world.h hello_world.c
  group power
    ./: power_hal_wait.c power_hal_wait.h power_drv.h power_drv.c
  group GestorAlarmas
    ./: gestorAlarma.h gestorAlarma.c
  group juego
    ./: juego.h juego.c escribirPorPantalla.h escribirPorPantalla.c
  group visualizar
    ./: visualizar.h visualizar.c
  group SWI
    ./: swi.h SWI.s
  group linea_serie
    ./: linea_serie_hal.h linea_serie_drv.h linea_serie_drv.c linea_serie_hal.c
  group Conecta
    ./: entrada.c entrada.h tablero.h tablero.c celda.h tablero_test.h config_conecta_K.h conecta_K_2023.c conecta_K_2023.h conecta_K_hay_linea_arm_armv2.s imprimirPorPantalla.c imprimirPorPantalla.h
