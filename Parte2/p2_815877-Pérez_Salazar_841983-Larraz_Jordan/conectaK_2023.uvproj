# Keil uVision project conectaK_2023.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: conecta_K_2023
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Assembly
    ./: Startup.s conecta_K_buscar_alineamiento_arm.s conecta_K_hay_linea_arm.s conecta_K_hay_linea_arm_arm.s conecta_K_hay_linea_arm_armv2.s
  group Includes
    ./: celda.h conecta_K_2023.h entrada.h tablero.h config_conecta_K.h tablero_test.h
  group Sources
    ./: conecta_K_2023.c main.c entrada.c tablero.c LPC210x.h
  group Drivers
    ./: temporizador_drv.c temporizador_drv.h
  group HAL
    ./: temporizador_hal.h temporizador_hal.c
