# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c Power_management.c Power_management.h boton_eint0.c boton_eint0.h timer0.c timer0.h
  group Drivers
    ./: temporizador_drv.h temporizador_drv.c
  group HAL
    ./: temporizador_hal.h temporizador_hal.c gpio_hal.h int_externas_hal.h int_externas_hal.c
  group AUX
    ./: io_reserva.h fifo.h eventos.h fifo.c planificador.h planificador.c botones.h botones.c
  group hello_world
    ./: hello_world.h hello_world.c
  group power
    ./: power_hal_wait.c power_hal_wait.h
  group GestorAlarmas
    ./: gestorAlarma.h gestorAlarma.c
  group juego
    ./: juego.h juego.c
  group visualizar
    ./: visualizar.h visualizar.c
